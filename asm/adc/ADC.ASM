#include<p16f877.inc>
ERRORLEVEL -302
ADC_H equ 0X21
ADC_L equ 0X22

	ORG 0X00
	GOTO MAIN
	ORG 0X04
	GOTO INTRPT

MAIN:
	BANKSEL TRISA
	BSF TRISA,0

	BANKSEL TRISD
	CLRF TRISD^0X80


	BANKSEL ADCON1
	MOVLW 0X80
	MOVWF ADCON1

	BANKSEL ADCON0
	MOVLW 0X81
	MOVWF ADCON0
here
	BANKSEL ADCON0
	BSF ADCON0,GO_DONE

LOOP:
	BTFSC ADCON0,GO_DONE
	GOTO LOOP

	BANKSEL ADRESL
	MOVFW ADRESL
    BANKSEL PORTD
	MOVWF PORTD
	BANKSEL 0X21
	MOVWF ADC_L
	MOVFW ADRESH
	BANKSEL 0X22
	MOVWF ADC_H

	
    goto  here
INTRPT:
RTFIE
 END



