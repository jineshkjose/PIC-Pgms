#INCLUDE"P16F877A.INC"
CBLOCK 0X20
R1
ENDC
ORG 0X00
BCF STATUS,6
BSF STATUS,5
MOVLW B'00000111'
MOVWF OPTION_REG
MOVLW 0X00
MOVWF TRISB

BCF STATUS,6
BCF STATUS,5
MOVLW 0X80
MOVWF R1
L1:
MOVF R1,0
MOVWF PORTB
CALL DELAY1
RRF R1,1
GOTO L1

DELAY1:
MOVLW 0X01
MOVWF TMR0
L2:
MOVF TMR0,0
BTFSS STATUS,2
GOTO L2
NOP
RETURN
END

